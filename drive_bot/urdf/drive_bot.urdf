Commit message: lidar issue

File: drive_bot/urdf/drive_bot.urdf (robot description, URDF)
Before this commit: robot drive_bot, 9 links, 8 joints
Joints:
- joint base_lidar_joint: origin xyz=0.0 0.0 0.225 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.4 rpy=0.0 0.0 0.0
